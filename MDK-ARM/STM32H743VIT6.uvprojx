# Keil uVision project STM32H743VIT6.uvprojx, settings and files
target STM32H743VIT6 (6230000::V6.23::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743VIT6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6LangP=7 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,USE_PWR_LDO_SUPPLY,ARM_MATH_CM7,ARM_MATH_DSP
  c misc: -D_LIBCPP_DISABLE_AVAILABILITY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Components/BSP/LED/Inc;../Components/BSP/USART/Inc;../Components/BSP/W25Q64/Inc;../Components/Logger/Inc;../Components/Motor/Inc;../Components/HardFaultLab/Inc;../Components/BSP/IMU/Inc;../Components/BSP/ESP/Inc;../Components/CMSIS_DSP/Include;../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Drivers/CMSIS/RTOS2/Include;../Components/Debug/Inc;../Components/Fault_Diagnosis/Inc;../Components/EdgeImpulse/model-parameters;../Components/EdgeImpulse/tflite-model;../Components/EdgeImpulse;D:/Keil_v5/ARM/ARMCLANG/include/libcxx;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Components/EdgeImpulse/edge-impulse-sdk;../Components/FreeRTOS_Port/ARM_CM4F;../Components/BSP/LOG/Inc;../Components/POSTest/Inc;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: STM32H743VIT6.sct
  link misc: --diag_suppress=L6200E
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c i2c.c iwdg.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group W25Q64
    ../Components/BSP/W25Q64/Src/: BSP_W25Q64.c
    ../Components/BSP/W25Q64/Inc/: BSP_W25Q64.h
  group IMU
    ../Components/BSP/IMU/Src/drivers/: imu_mpu6050.c mag_qmc5883l.c
    ../Components/BSP/IMU/Src/fusion/: imu_filter.c madgwick.c
    ../Components/BSP/IMU/Src/: attitude.c
    ../Components/BSP/IMU/Inc/: attitude.h imu_filter.h imu_mpu6050.h madgwick.h
  group Motor
    ../Components/Motor/Src/: motor.c
    ../Components/Motor/Inc/: motor.h
  group Fault_Diagnosis
    ../Components/Fault_Diagnosis/Inc/: model_weights.h test_dataset_processed.h test_dataset_raw.h ai_config.h ai_infer.h fuzzy_frontend.h fuzzy_lut.h model_q_params.h model_weights_ext.h model_weights_q.h
    ../Components/Fault_Diagnosis/Src/: fuzzy_frontend.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group CMSIS_DSP
    ../Components/CMSIS_DSP/Source/BasicMathFunctions/: arm_dot_prod_f32.c arm_add_f32.c
    ../Components/CMSIS_DSP/Source/MatrixFunctions/: arm_mat_init_f32.c arm_mat_mult_f32.c
    ../Components/CMSIS_DSP/Source/StatisticsFunctions/: arm_max_f32.c
  group Middlewares/FreeRTOS
    ../Components/FreeRTOS_Port/ARM_CM4F/: port.c portmacro.h
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers_v2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Debug
    ../Components/BSP/LOG/Inc/: BSP_LOG.h
    ../Components/BSP/LOG/Src/: BSP_LOG.c
    ../Components/Logger/Inc/: logger.h
    ../Components/Logger/Src/: logger.c
    ../Components/Debug/Src/: dbg_telemetry.c vofa_telemetry.c watchdog_heartbeat.c
    ../Components/Debug/Inc/: dbg_config.h dbg_telemetry.h vofa_telemetry.h app_config.h watchdog_heartbeat.h
    ../Components/BSP/LED/Src/: led.c
    ../Components/BSP/LED/Inc/: led.h
  group FaultDiag_NN
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_s8.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_vec_mat_mult_t_s8.c
    ../Components/Fault_Diagnosis/Src/: ai_infer.c
  group EdgeImpluse_NN
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_wrapper_s16.c arm_depthwise_conv_s16.c arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_fast_s16.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_fast_s16.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s16.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_s8.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mat_mult_nt_t_s8.c arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_s16.c arm_softmax_s8_s16.c arm_nn_softmax_common_s8.c arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s8.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s16.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s16.c arm_max_pool_s8.c arm_pool_q7_HWC.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    ../Components/EdgeImpulse/edge-impulse-sdk/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c
    ../Components/EdgeImpulse/edge-impulse-sdk/dsp/: memory.cpp
    ../Components/EdgeImpulse/edge-impulse-sdk/tensorflow/lite/core/api/: common.cpp flatbuffer_conversions.cpp op_resolver.cpp tensor_utils.cpp
    ../Components/EdgeImpulse/edge-impulse-sdk/tensorflow/lite/kernels/custom/: tree_ensemble_classifier.cpp
    ../Components/EdgeImpulse/edge-impulse-sdk/tensorflow/lite/kernels/internal/: portable_tensor_utils.cpp quantization_util.cpp tensor_utils.cpp
    ../Components/EdgeImpulse/edge-impulse-sdk/tensorflow/lite/micro/: micro_allocation_info.cpp micro_graph.cpp micro_log.cpp micro_resource_variable.cpp micro_time.cpp micro_utils.cpp mock_micro_graph.cpp non_persistent_arena_buffer_allocator.cpp persistent_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp schema_utils.cpp single_arena_buffer_allocator.cpp all_ops_resolver.cpp fake_micro_context.cpp flatbuffer_conversions_bridge.cpp flatbuffer_utils.cpp memory_helpers.cpp micro_allocator.cpp micro_context.cpp micro_error_reporter.cpp micro_interpreter.cpp micro_profiler.cpp micro_string.cpp recording_micro_allocator.cpp
    ../Components/EdgeImpulse/edge-impulse-sdk/tensorflow/lite/micro/kernels/: activations.cpp activations_common.cpp add_n.cpp arg_min_max.cpp assign_variable.cpp batch_matmul.cpp batch_to_space_nd.cpp broadcast_args.cpp broadcast_to.cpp call_once.cpp cast.cpp ceil.cpp circular_buffer.cpp comparisons.cpp complex_abs.cpp concatenation.cpp cumsum.cpp depth_to_space.cpp dequantize.cpp dequantize_common.cpp detection_postprocess.cpp div.cpp elementwise.cpp elu.cpp ethosu.cpp exp.cpp expand_dims.cpp fill.cpp floor.cpp floor_div.cpp floor_mod.cpp fully_connected.cpp fully_connected_common.cpp gather.cpp gather_nd.cpp hard_swish.cpp hard_swish_common.cpp if.cpp l2norm.cpp l2_pool_2d.cpp leaky_relu.cpp leaky_relu_common.cpp logical.cpp logical_common.cpp logistic.cpp logistic_common.cpp log_softmax.cpp lstm_eval.cpp maximum_minimum.cpp mirror_pad.cpp mul.cpp mul_common.cpp neg.cpp pack.cpp pad.cpp pooling.cpp pooling_common.cpp prelu.cpp prelu_common.cpp quantize.cpp quantize_common.cpp read_variable.cpp real.cpp reduce.cpp reduce_common.cpp reshape.cpp resize_bilinear.cpp resize_nearest_neighbor.cpp rfft2d.cpp round.cpp scatter_nd.cpp select.cpp shape.cpp slice.cpp space_to_batch_nd.cpp space_to_depth.cpp split.cpp split_v.cpp squared_difference.cpp squeeze.cpp strided_slice.cpp sub.cpp sub_common.cpp svdf.cpp svdf_common.cpp tanh.cpp tile.cpp topk_v2.cpp transpose.cpp transpose_conv.cpp tree_ensemble_classifier.cpp unidirectional_sequence_lstm.cpp unpack.cpp var_handle.cpp while.cpp zeros_like.cpp conv.cpp conv_common.cpp depthwise_conv.cpp depthwise_conv_common.cpp add.cpp add_common.cpp softmax.cpp softmax_common.cpp kernel_runner.cpp kernel_util_micro.cpp micro_tensor_utils.cpp scratch_buffers.cpp scratch_buf_mgr.cpp
    ../Components/EdgeImpulse/edge-impulse-sdk/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cpp linear_memory_planner.cpp
    ../Components/EdgeImpulse/edge-impulse-sdk/porting/stm32-cubeai/: debug_log.cpp ei_classifier_porting.cpp
    ../Components/EdgeImpulse/tflite-model/: tflite_learn_638348_4_compiled.cpp tflite_learn_638348_4_compiled.h trained_model_ops_define.h
  group ESP
    ../Components/BSP/ESP/Inc/: esp01s.h esp32s3.h esp01s_config_local.h
    ../Components/BSP/ESP/Src/: esp01s.c esp32s3.c uart_rx_dispatcher.c
  group POSTest
    ../Components/POSTest/Src/: Postest.c
    ../Components/POSTest/Inc/: Postest.h
software components: CMSIS:CORE 6.1.0
